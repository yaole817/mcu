# Keil uVision project first_proj.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051 Evatronix
  cpu: IRAM(0-0x7F)  CLOCK(12000000) MODC2
  output: mcu_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
